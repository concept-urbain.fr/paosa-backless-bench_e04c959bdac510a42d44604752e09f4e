Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Paosa Banquette.IFC
Time: 2020-07-01T09:23:41
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: PAO-MUL-001_Default (2)
In: Default Storey
Name
PAO-MUL-001_Default | PSet_Mass_Property - Mass Measure: 24.1389; Area Measure: 2.37344; Volume Measure: 0.00568114
PAO-MUL-001_Default

# IfcBuildingElementProxy: PAO-TRESPA-MUL-45X140-001_Default
In: Default Storey
Material: Trespa
